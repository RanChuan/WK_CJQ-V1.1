# Keil uVision project 工程模板.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程模板 +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\user;.\APP;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\temhum;.\APP\collect;.\APP\TVOC;.\APP\PM2.5;.\APP\timeinter;.\APP\collect;.\SPG30
  memory RVCT4: ROM 0x8002800 size 0xd800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c
    ./startup/: startup_stm32f10x_md.s
  group stdperiph_Drive
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_iwdg.c
  group APP
    ./APP/temhum/: sht21.c myiic.c
    ./APP/: sys.c delay.c deal.c crc8_16.c drv_AS62.c led.c flash.c kqm2801A.c usart3.c usart1.c light.c key.c wdg.c
    ./APP/TVOC/: data.c
    ./APP/collect/: collect.c
    ./APP/timeinter/: interruptdef.c
  group SPG30
    ./SPG30/: sensirion_common.c sensirion_sw_i2c.c sgp30.c sgp30_featureset.c
software components: CMSIS:CORE 4.3.0
